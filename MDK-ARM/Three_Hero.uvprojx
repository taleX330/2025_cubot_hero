# Keil uVision project Three_Hero.uvprojx, settings and files
target Three_Hero (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Three_Hero +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ARM/DSP;../Middlewares/ARM/DSP/Include;../Middlewares/ARM/DSP/Include/dsp;../Middlewares/ARM/DSP/Source;../Middlewares/ARM/DSP/Source/BasicMathFunctions;../Middlewares/ARM/DSP/Source/CommonTables;../Middlewares/ARM/DSP/Source/FastMathFunctions;../Middlewares/ARM/DSP/Source/MatrixFunctions;../Middlewares/ARM/DSP/Source/QuaternionMathFunctions;../CUBOT/Cubut_Drivers;../CUBOT/Cubot_Algorithm;../CUBOT/Cubot_Tasks;..\CUBOT\Cubot_Devices
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
  group Application/User
    ../Src/: main.c gpio.c dma.c fdcan.c i2c.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Cubut_Drivers
    ../CUBOT/Cubut_Drivers/: driver_can.c driver_counter.c driver_iic.c driver_spi.c driver_timer.c driver_usart.c
  group Cubot_Devices
    ../CUBOT/Cubot_Devices/: rm_motor.c brain.c supercap.c bmi088.c mpu6050.c ano_vofa.c dr16.c et08.c hwt906.c external_ecd.c hiwonder.c
  group Cubot_Algorithm
    ../CUBOT/Cubot_Algorithm/: ins.c pid.c ladrc.c filter.c user_lib.c kalman_filter.c quaternions_EKF.c
  group Cubot_Task
    ../CUBOT/Cubot_Tasks/: hero_task.c chassis_task.c holder_task.c shoot_task.c remote_ctrl_task.c online_ctrl_task.c referee_task.c
  group DSP
    ../Middlewares/ARM/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../Middlewares/ARM/DSP/Source/CommonTables/: CommonTables.c
    ../Middlewares/ARM/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../Middlewares/ARM/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../Middlewares/ARM/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
software components: CMSIS:CORE 4.3.0
